# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\快充诱骗管理芯片
  group Source Group 1
    ./: main.c STC8G_H_Delay.c STC8G_H_Delay.h STC8G_H_EEPROM.c STC8G_H_EEPROM.h STC8G_H_GPIO.c STC8G_H_GPIO.h
